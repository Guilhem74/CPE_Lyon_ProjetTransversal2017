# Keil uVision project projet_transversal_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: projet_transversal_1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LIB_PROJET_T_RESET.c LIB_PROJET_T_ADC.c LIB_PROJET_T_Clock.c LIB_PROJET_T_Config_Globale.c LIB_PROJET_T_DAC.C LIB_PROJET_T_GPIO.c LIB_PROJET_T_INT_Ext.c LIB_PROJET_T_Timers.c LIB_PROJET_T_UART.c UART0_RingBuffer_lib.C main.c c8051F020.h CFG_Globale.h LIB_PROJET_T_ADC.h LIB_PROJET_T_Clock.h LIB_PROJET_T_Config_Globale.h LIB_PROJET_T_DAC.h LIB_PROJET_T_GPIO.h LIB_PROJET_T_INT_Ext.h LIB_PROJET_T_Timers.h LIB_PROJET_T_UART.h UART0_RingBuffer_lib.h
